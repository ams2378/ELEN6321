x1NOR2XLTS nand_o prechrg_i n5 gnd vdd NOR2XLTS
x2AND2XLTS a_i b_i n5 gnd vdd AND2XLTS
x3AND2XLTS b_i n6 and_o gnd vdd AND2XLTS
x4NOR2BX1TS n6 a_i prechrg_i gnd vdd NOR2BX1TS

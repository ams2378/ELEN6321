x1INVXLTS n9 b_i gnd vdd INVXLTS
x2INVXLTS n10 n9 gnd vdd INVXLTS
x3INVXLTS n11 prechrg_i gnd vdd INVXLTS
x4INVXLTS n12 n11 gnd vdd INVXLTS
x5INVXLTS n13 a_i gnd vdd INVXLTS
x6INVXLTS n14 n13 gnd vdd INVXLTS
x7NOR2XLTS nor_o n14 n16 gnd vdd NOR2XLTS
x8OR2XLTS n12 n10 n16 gnd vdd OR2XLTS
x9NOR2XLTS or_o n12 n15 gnd vdd NOR2XLTS
x10NOR2XLTS n15 n14 n10 gnd vdd NOR2XLTS

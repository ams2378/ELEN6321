x1INVXLTS n1 d1_n_in gnd vdd INVXLTS
x2INVXLTS n2 n1 gnd vdd INVXLTS
x3INVXLTS n3 d1_p_in gnd vdd INVXLTS
x4INVXLTS n4 n3 gnd vdd INVXLTS
x5INVXLTS n5 d0_p_in gnd vdd INVXLTS
x6INVXLTS n6 n5 gnd vdd INVXLTS
x7INVXLTS n7 d0_n_in gnd vdd INVXLTS
x8INVXLTS n8 n7 gnd vdd INVXLTS
x9OA22X1TS d_n_out n8 n4 n6 n2 gnd vdd OA22X1TS
x10AO22X1TS d_p_out n8 n4 n6 n2 gnd vdd AO22X1TS

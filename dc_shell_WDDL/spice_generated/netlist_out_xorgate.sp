x1INVXLTS n1 d0_p_in gnd vdd INVXLTS
x2INVXLTS n2 n1 gnd vdd INVXLTS
x3INVXLTS n3 d1_p_in gnd vdd INVXLTS
x4INVXLTS n4 n3 gnd vdd INVXLTS
x5XOR2X1TS d_p_out n4 n2 gnd vdd XOR2X1TS

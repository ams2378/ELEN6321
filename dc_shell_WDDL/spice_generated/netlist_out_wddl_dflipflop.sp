x1DFFQX1TS qbar_o clk d_bar_o gnd vdd DFFQX1TS
x2DFFTRX2TS clk n7 q_o nett_0 n8 gnd vdd DFFTRX2TS
x3NOR2BX1TS d_bar_o n8 n7 gnd vdd NOR2BX1TS
x4INVX1TS n7 n6 gnd vdd INVX1TS
x5INVXLTS n6 d_i gnd vdd INVXLTS
x6INVXLTS n8 prechrg_i gnd vdd INVXLTS

x1XNOR2X1TS n30 lfsr_out23 lfsr_out16 XNOR2X1TS
x2DFFSXLTS n27 lfsr_out1 clk n28 n34 DFFSXLTS
x3DFFSXLTS n26 lfsr_out2 clk n27 n36 DFFSXLTS
x4DFFSXLTS n25 lfsr_out3 clk n26 n34 DFFSXLTS
x5DFFSXLTS n24 lfsr_out4 clk n25 n34 DFFSXLTS
x6DFFSXLTS n23 lfsr_out5 clk n24 n35 DFFSXLTS
x7DFFSXLTS n22 lfsr_out6 clk n23 n35 DFFSXLTS
x8DFFSXLTS n21 lfsr_out7 clk n22 n35 DFFSXLTS
x9DFFSXLTS n20 lfsr_out8 clk n21 n35 DFFSXLTS
x10DFFSXLTS n19 lfsr_out9 clk n20 n32 DFFSXLTS
x11DFFSXLTS n18 lfsr_out10 clk n19 n38 DFFSXLTS
x12DFFSXLTS n17 lfsr_out11 clk n18 n38 DFFSXLTS
x13DFFSXLTS n16 lfsr_out12 clk n17 n39 DFFSXLTS
x14DFFSXLTS n15 lfsr_out13 clk n16 n36 DFFSXLTS
x15DFFSXLTS n14 lfsr_out14 clk n15 n36 DFFSXLTS
x16DFFSXLTS n13 lfsr_out15 clk n14 n36 DFFSXLTS
x17DFFSXLTS n11 lfsr_out17 clk n12 n39 DFFSXLTS
x18DFFSXLTS n10 lfsr_out18 clk n11 n40 DFFSXLTS
x19DFFSXLTS n9 lfsr_out19 clk n10 n40 DFFSXLTS
x20DFFSXLTS n8 lfsr_out20 clk n9 n37 DFFSXLTS
x21DFFSXLTS n7 lfsr_out21 clk n8 n37 DFFSXLTS
x22DFFSXLTS n6 lfsr_out22 clk n7 n37 DFFSXLTS
x23DFFSXLTS n4 lfsr_out24 clk n5 n38 DFFSXLTS
x24DFFSXLTS n3 lfsr_out25 clk n4 n41 DFFSXLTS
x25DFFSXLTS n2 lfsr_out26 clk n3 n41 DFFSXLTS
x26DFFSXLTS n12 lfsr_out16 clk n13 n40 DFFSXLTS
x27DFFSXLTS n5 lfsr_out23 clk n6 n37 DFFSXLTS
x28DFFSXLTS nett_0 lfsr_out27 clk n2 n41 DFFSXLTS
x29DFFRX1TS lfsr_out0 n28 clk N1 n34 DFFRX1TS
x30XOR2X1TS n29 lfsr_out0 n30 XOR2X1TS
x31XOR2X1TS N1 lfsr_out27 n29 XOR2X1TS
x32INVXLTS n31 resetn INVXLTS
x33INVXLTS n32 n31 INVXLTS
x34CLKBUFX2TS n35 n32 CLKBUFX2TS
x35CLKBUFX2TS n36 n39 CLKBUFX2TS
x36CLKBUFX2TS n37 n38 CLKBUFX2TS
x37CLKBUFX2TS n38 n41 CLKBUFX2TS
x38CLKBUFX2TS n41 n32 CLKBUFX2TS
x39CLKBUFX2TS n34 n39 CLKBUFX2TS
x40CLKBUFX2TS n39 n40 CLKBUFX2TS
x41CLKBUFX2TS n40 n32 CLKBUFX2TS
